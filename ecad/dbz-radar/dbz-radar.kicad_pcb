# Repository extralongdivision/dbz-radar

File README.md:

# Dragon Ball Radar

|                                        |                                                              |
|:--------------------------------------:|:------------------------------------------------------------:|
|  |  |

The radar from [Akira Toriyama's *Dragon Ball* series](https://en.wikipedia.org/wiki/Dragon_Ball "Dragon Ball") is now more realistic than ever! This repository contains everything needed to reproduce the project.

For step-by-step directions on how to build the Dragon Radar, please go to [extralongdivision.com/projects/dbz-radar/dbz-radar-tutorial/.](http://extralongdivision.com/projects/dbz-radar/dbz-radar-tutorial/?utm_source=codeberg&utm_medium=organic_social&utm_content=dbz-radar)

For in-depth rationale of the design decisions, please read the [latest development log.](http://extralongdivision.com/projects/dbz-radar/dbz-radar-devlog-2/?utm_source=codeberg&utm_medium=organic_social&utm_content=dbz-radar)

## Project Overview

### License

Everything in this repository is free as in freedom. You can reuse, remix, and reproduce any and all parts of this project as defined by the following:

- Source code is Apache-2.0 licensed

- Documentation and media is Creative Commons Share Alike Attribution 4.0 International

- Hardware is distributed Solderpad Hardware License 2.1

### Capabilities

Pressing and holding the button will turn the radar on and off. Once on, a speaker will beep periodically and the screen will display the a static green grid like in the series. Currently, there are no corresponding dragon balls that the radar detects nor does the screen have any animations.

### Hardware

The mechanical parts were designed for 3D printing. You can find them in the `mcad` directory.

Board manufacturing files are available in `ecad/dbz-radar/production/V1-1/`. You can also generate your own files from the provided KiCAD project. Below is the schematic for the board for convenience.

### Software

The provided source code is written in CircuitPython. The microcontroller is an ESP32-S3, so can you use any other compatible tool-chain to replace or change the firmware.

## Directory Structure

Find the files you need using the descriptions below.

`bin` binaries needed to program the board

`datasheets`for components

`ecad` electronic design project files

`examples` code to ensure hardware works as expected

`graphics-projects` project files used for images displayed on the radar's screen

`LICENSES` for the components of this project

`mcad` mechanical design files for 3D printing or modification

`media`photos used in this README

`src` source code to be copied to the `CIRCUITPY` drive that make the hardware function like a Dragon Radar

## KiCad design ecad/dbz-radar/dbz-radar.kicad_pcb

Parts:
C1, C3, C6, C9, C11, C14, C16, C19: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; MFG PN TCC0805X7R106K160FT; LCSC C380347
C2, C7, C12, C13, C15, C17, C20, C21, C24: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; MFG PN CC0805KRX7R9BB104; LCSC C49678
C5: 100uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder; MFG PN CL31A107MQHNNNE; LCSC C15008
C8, C10, C18: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; MFG PN CL21B105KBFNNNE; LCSC C28323
C22, C23: DNI; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; MFG PN DNI; LCSC DNI; not fitted
D1, D3: ESD5Zxx; D_SOD-523; MFG PN ESD5Z5V0; LCSC C502546
D4, D6, D8, D9: LED_Small; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; MFG PN KT-0805R; LCSC C2295
D5, D7: MBR0540; D_SOD-123; MFG PN MBR0540; LCSC C77337
FID1, FID2, FID3: Fiducial; Fiducial_1mm_Mask2mm
H1, H2, H3, H4, H5, H6: MountingHole_Pad; M1-mounting-hole
J1: B2B-PH-SM4-TB; MFG PN B2B-PH-SM4-TB; LCSC C160352
J2: USB4220-03-0880-C; USB4220-03; MFG PN USB4220-03-0880-C; LCSC C41730496
J3: XF2M-4015-1A; XF2M-4015-1A_alt; MFG PN XF2M-4015-1A; LCSC C225713
J4: 533980271; Molex_PicoBlade_53398-0271_1x02-1MP_P1.25mm_Vertical; MFG PN 533980271; LCSC C122410
J5: DNI; PinHeader_1x14_P2.54mm_Vertical; MFG PN DNI; LCSC DNI; not fitted
L1: 6.8uH; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder; MFG PN MLZ2012N6R8LT000; LCSC C82157
Q1: Q_PMOS; SOT-23; MFG PN Alpha & Omega Semicon; LCSC C15127
R1, R2, R4, R10, R11, R12, R30, R31, R32, R33, R35, R70, R71: 5.1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN 0805W8F5101T5E; LCSC C27834
R3, R5, R8, R13, R14, R15, R17, R20, R21, R22, R23, R25, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R72: 0; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN 0805W8F0000T5E; LCSC C17477
R6: 10; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN 0805W8F100JT5E; LCSC C17415
R7, R9, R19, R27, R29: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN 0805W8F1000T5E; LCSC C17408
R16, R18, R24, R26, R28, R34, R36: DNI; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; MFG PN DNI; LCSC DNI; not fitted
SW1, SW2: SKRPACE010; MFG PN SKRPACE010; LCSC C139797
SW3: 1-825027-7; MFG PN 1-825027-7; LCSC C592923
TP1, TP2, TP3, TP4, TP5, TP6, TP8, TP10, TP14: TestPoint; TestPoint_Pad_D2.0mm
U1: USBLC6-2SC6; SOT-23-6_Handsoldering; MFG PN USBLC6-2SC6; LCSC C5180249
U2: TPS61169; SOT-353_SC-70-5; MFG PN TPS61169; LCSC C71045
U3: MCP738311/2; SOT-23-5_HandSoldering; MFG PN MCP73831T-2ACI/OT; LCSC C424093
U4: MAX17048/9; MAX1704X; MFG PN MAX17048X+T10; LCSC C7497002
U5: AP2112K-3.3; SOT-23-5_HandSoldering; MFG PN AP2112K-3.3TRG1(MS); LCSC C22365427
U6: PCA9554; TSSOP-16_4.4x5mm_P0.65mm; MFG PN PCA9554PWR; LCSC C2873588
U7: MAX98357A; MAX98357XTEXX; MFG PN MAX98357A; LCSC C910544
U8: ESP32-S3-WROOM-1-N16R8; ESP32-S3-WROOM-1_Alt; MFG PN ESP32-S3-WROOM-1-N16R8; LCSC C2913202

Connections:
+3V3: C1.1, C2.1, C12.1, C15.1, C16.1, C17.1, C19.1, C20.1, C21.2, D8.2 (A), J3.5, J3.39, J5.13, L1.1, R2.1, R12.2, R15.1, R17.2, R21.2, R22.1, R23.1, R25.1, R30.2, R31.2, R32.2, R33.1, R34.2, R35.2, R55.2, R70.2, R71.2, TP10.1 (1_1), U2.5 (VIN), U6.16 (VCC), U8.2 (3V3)
+24V: C8.2, C10.2, D5.1 (K), J3.1, TP6.1 (1_1)
+BATT: C6.1, C13.2, Q1.3 (D), R5.2, R8.1, TP4.1 (1_1), U4.2 (CELL), U4.3 (Vdd)
/A0: R58.2, U7.16 (BCLK)
/A1: R45.1, U7.1 (DIN)
/B1: J3.16, J3.17, R61.2
/B2: J3.18, R66.2
/B3: J3.19, R60.2
/B5: J3.21, R68.2
/BACKLIGHT: R2.2, TP2.1 (1_1), U2.4 (CTRL), U6.9 (P4)
/BATT_CONN: D1.1 (K), J1.1, R5.1
/BATT_MONITOR-QSTRT: J5.10, R14.2, U4.6 (QSTRT)
/BOOT0_B4: J3.20, R37.1, SW2.2
/CS: J5.5, R31.1, R54.1
/DE: J3.13, R38.1
/G0: J3.22, R64.2
/G1: J3.23, R69.2
/G2: J3.24, R59.2
/G3: J3.25, R44.1
/G4: J3.26, R53.1
/G5: J3.27, R43.1
/HB_LED: D9.2 (A), U6.10 (P5)
/HSYNC: J3.15, R67.2
/I2C_IO_P6: J5.11, U6.11 (P6)
/IM0: J3.8, R15.2, R16.2
/IM1: J3.7, R17.1, R18.1
/IO35: J5.8, U8.28 (IO35)
/IO36: J5.7, U8.29 (IO36)
/IO37: J5.6, U8.30 (IO37)
/LEDK: C7.1, J3.2, J3.3, R6.1, TP5.1 (1_1), U2.3 (FB)
/MISO: J5.3, R40.1
/MOSI: J5.4, R50.1
/PCLK: R19.1, R47.1
/PCLK_CONN: J3.12, R19.2
/R1: J3.28, J3.29, R52.1
/R2: J3.30, R42.1
/R3: J3.31, R51.1
/R4: J3.32, R63.2
/R5: J3.33, R48.1
/RXD0: R65.2, U7.14 (LRCLK)
/SCK: J5.2, R49.1
/SCL: J3.37, R70.1, R72.2, U4.7 (SCL), U6.14 (SCL)
/SDA: J3.36, R30.1, R41.1, U4.8 (SDA), U6.15 (SDA)
/TFT_CS: J3.11, R12.1, U6.5 (P1)
/TFT_MOSI: J3.9, U6.12 (P7)
/TFT_RESET: J3.6, J3.38, U6.6 (P2)
/TFT_SCK: J3.10, U6.4 (P0)
/TP_IRQ: J3.35, U6.7 (P3)
/TXD0: J5.1, U8.37 (TXD0)
/USB_D+: J2.A6 (D+), J2.B6 (D+), U1.1 (I/O1), U1.6 (I/O1), U8.14 (USB_D+)
/USB_D-: J2.A7 (D-), J2.B7 (D-), U1.3 (I/O2), U1.4 (I/O2), U8.13 (USB_D-)
/USER: C24.1, R39.1, R71.1, SW3.2
/VBUS_CONN: J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), R3.1
/VSYNC: J3.14, R62.2
/Vin: C14.1, R13.2, R20.1, TP8.1 (1_1), U5.1 (VIN)
/~BATT_ALRT: J5.9, U4.5 (~ALRT)
/~EXP_IRQ: J5.12, R33.2, U6.13 (~INT)
/~RESET: C18.2, R32.1, R46.1, SW1.2, TP14.1 (1_1)
GND: C1.2, C2.2, C3.1, C5.2, C6.2, C7.2, C8.1, C9.2, C10.1, C11.1, C12.2, C13.1, C14.2, C15.2, C16.2, C17.2, C18.1, C19.2, C20.2, C21.1, C22.2, C23.2, C24.2, D1.2 (A), D3.2 (A), H1.1 (1_1), H2.1 (1_1), H3.1 (1_1), H4.1 (1_1), H5.1 (1_1), H6.1 (1_1), J1.2, J1.MP (MountPin), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.MP, J3.4, J3.34, J3.40, J3.MP (MountPin), J4.MP (MountPin), J5.14, R1.1, R4.1, R6.2, R9.2, R10.2, R11.1, R14.1, R16.1, R18.2, R24.1, R26.2, R27.2, R28.2, R29.1, R36.1, SW1.1, SW2.1, SW3.1, SW3.MP, TP1.1 (1_1), U1.2 (GND), U2.2 (GND), U3.2 (Vss), U4.1 (CTG), U4.4 (GND), U4.9 (EP), U5.2 (GND), U6.8 (GND), U7.3 (GND), U7.11 (GND), U7.15 (GND), U7.17 (PAD), U8.1 (GND), U8.40 (GND), U8.41 (GND)
unnamed: D4.1 (K), R7.1
unnamed: D5.2 (A), L1.2, U2.1 (SW)
unnamed: D6.1 (K), R9.1
unnamed: D7.1 (K), Q1.2 (S), R13.1
unnamed: D8.1 (K), R27.1
unnamed: D9.1 (K), R29.2
unnamed: J2.A5 (CC1), R1.2
unnamed: J2.B5 (CC2), R4.2
unnamed: C23.1, J4.1, R56.2
unnamed: C22.1, J4.2, R57.2
unnamed: R55.1, U7.7 (VDD), U7.8 (VDD)
unnamed: R10.1, U3.5 (PROG)
unnamed: R7.2, U3.1 (STAT)
unnamed: C11.2, R8.2, U3.3 (Vbat)
unnamed: R20.2, U5.3 (EN)
unnamed: R21.1, U5.5 (VOUT)
unnamed: R25.2, R28.1, U6.1 (A0)
unnamed: R22.2, R26.1, U6.2 (A1)
unnamed: R23.2, R24.2, U6.3 (A2)
unnamed: R34.1, R36.2, U7.2 (GAIN_SLOT)
unnamed: R57.1, U7.10 (OUTN)
unnamed: R56.1, U7.9 (OUTP)
unnamed: R35.1, U7.4 (~SD_MODE)
unnamed: R46.2, U8.3 (EN)
unnamed: R37.2, U8.27 (IO0)
unnamed: R47.2, U8.39 (IO1)
unnamed: R38.2, U8.38 (IO2)
unnamed: R48.2, U8.15 (IO3)
unnamed: R39.2, U8.4 (IO4)
unnamed: R49.2, U8.5 (IO5)
unnamed: R40.2, U8.6 (IO6)
unnamed: R50.2, U8.7 (IO7)
unnamed: R41.2, U8.12 (IO8)
unnamed: R51.2, U8.17 (IO9)
unnamed: R42.2, U8.18 (IO10)
unnamed: R52.2, U8.19 (IO11)
unnamed: R43.2, U8.20 (IO12)
unnamed: R53.2, U8.21 (IO13)
unnamed: R44.2, U8.22 (IO14)
unnamed: R54.2, U8.8 (IO15)
unnamed: R45.2, U8.9 (IO16)
unnamed: R58.1, U8.10 (IO17)
unnamed: R72.1, U8.11 (IO18)
unnamed: R59.1, U8.23 (IO21)
unnamed: R60.1, U8.31 (IO38)
unnamed: R66.1, U8.32 (IO39)
unnamed: R61.1, U8.33 (IO40)
unnamed: R67.1, U8.34 (IO41)
unnamed: R62.1, U8.35 (IO42)
unnamed: R68.1, U8.26 (IO45)
unnamed: R63.1, U8.16 (IO46)
unnamed: R69.1, U8.24 (IO47)
unnamed: R64.1, U8.25 (IO48)
unnamed: R65.1, U8.36 (RXD0)
VBUS: C3.2, C5.1, C9.1, D3.1 (K), D4.2 (A), D6.2 (A), D7.2 (A), Q1.1 (G), R3.2, R11.2, TP3.1 (1_1), U1.5 (VBUS), U3.4 (Vdd)

Notes on the sheet:
HD40015C40
Audio
Power
MCU/IO
J3 must have bottom-side contacts
As configured, Adafruit says the I2C address is 0x3F, but the datasheet says it should be 0x27. ¯\_(ツ)_/¯ https://learn.adafruit.com/adafruit-qualia-esp32-s3-for-rgb666-displays/pinouts
Set charge rate with pulldown on PROG
I2C Address: 0x36

Board: 4 copper layers, 125.2 x 122.2 mm, 139 parts (0 on the bottom side), 114 nets.

## Commit log (part)

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2026-06-28 patch CircuitPython link in README
2026-06-29 add test code for audio playing from SD card
